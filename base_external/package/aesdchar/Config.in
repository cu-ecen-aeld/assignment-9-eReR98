## base_external/package/aesdchar/Config.in
```kconfig
config BR2_PACKAGE_AESDCHAR
	bool "AESDCHAR"
	depends on BR2_LINUX_KERNEL
	help
	  Includes packages for assignment 8
```
